# Keil uVision project i2clcd.uvprojx, settings and files
target i2clcd (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: i2clcd +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\lib\src;.\lib\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Src
    ./: main.c LCD_I2C.c i2c.c delay.c MPU_I2C.c LED.c Switch.c TIMER.c
  group lib
    ./lib/src/: stm32f10x_gpio.c stm32f10x_i2c.c misc.c stm32f10x_rcc.c
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.0
